FILESEXTRAPATHS_prepend := "${THISDIR}/nspr-4.16:"
SRC_URI += "file://0001-Add-ilp32-support.patch"

