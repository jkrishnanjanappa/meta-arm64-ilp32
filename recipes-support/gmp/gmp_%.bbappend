EXTRA_OECONF_append_linux-gnuilp32 = " --disable-assembly "
