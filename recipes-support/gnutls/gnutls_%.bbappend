FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://gnutls-ilp32.patch"

